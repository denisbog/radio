options:
  parameters:
    generate_options: qt_gui
    id: fmradio
    output_language: python
    title: FM radio
  states: {}

blocks:
- name: band_width
  id: variable
  parameters:
    value: 1.75e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(samp_rate / quadrature_rate)
  states: {}
- name: freq
  id: variable
  parameters:
    value: hardware_freq+tune
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: hardware_freq
  id: variable_qtgui_range
  parameters:
    start: 169e6
    step: 1e6
    stop: 169e6
    value: 169e6
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 100e3
    stop: 5e6
    value: 500e3
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(50e3)
    max_dev: 5e3
    quad_rate: int(quadrature_rate)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-20'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/denis/Desktop/recorded
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-tune'
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '8'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: band_width
    fc: hardware_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: band_width
    fc: freq
    fftsize: '2048'
    grid: 'True'
    name: after low pass filter
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: band_width
    fc: freq
    fftsize: '2048'
    grid: 'True'
    name: after low pass filter
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: after low pass filter
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    name: waterfall
    type: complex
    update_time: '0.0010'
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: band_width
    center_freq: hardware_freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
    vga: '0'
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_file_source_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
